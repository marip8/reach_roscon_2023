Commit message: Moved the bin

File: 2_pick_and_place_reach_study/resources/reach_study.xacro (robot description, xacro)
@@ -13,5 +13,5 @@
     <parent link="base_link"/>
     <child link="bin"/>
-    <origin xyz="0.5 0.0 0.0"/>
+    <origin xyz="0.5 0.3 0.25"/>
   </joint>
 </robot>
